/*
 * ringkit — polyphase resampler. See ring_resample.h.
 *
 * The coefficient tables are generated by tools/gen_ws_resampler.py into
 * ring_resample_coeffs.c.
 */
#include "ringkit/ring_resample.h"

#include <string.h>

/* Coefficients generated by tools/gen_ws_resampler.py. */
extern const float ring_resample_decim_coeffs[RING_RESAMPLE_DECIM_PHASES][RING_RESAMPLE_DECIM_PHASE_LEN];
extern const float ring_resample_interp_coeffs[RING_RESAMPLE_INTERP_PHASES][RING_RESAMPLE_INTERP_PHASE_LEN];

/* ---- 48k → 16k decimator ---- */

void ring_resample_decim_init(ring_resample_decim_t *s)
{
    if (s != NULL) {
        memset(s->history, 0, sizeof(s->history));
    }
}

int ring_resample_decim_process(ring_resample_decim_t *s,
                                const float *input, int n_in,
                                float *output)
{
    if (s == NULL || input == NULL || output == NULL || n_in <= 0) {
        return 0;
    }
    int n_out = 0;
    int want = n_in / RING_RESAMPLE_DECIM_PHASES;
    const float *hist = s->history;
    int hlen = RING_RESAMPLE_DECIM_HIST_LEN;

    for (int n = 0; n < want; n++) {
        float acc = 0.0f;
        for (int p = 0; p < RING_RESAMPLE_DECIM_PHASES; p++) {
            const float *cp = ring_resample_decim_coeffs[p];
            for (int k = 0; k < RING_RESAMPLE_DECIM_PHASE_LEN; k++) {
                int t = RING_RESAMPLE_DECIM_PHASES * n - p - RING_RESAMPLE_DECIM_PHASES * k;
                float x;
                if (t < 0) {
                    int hidx = t + hlen;
                    x = (hidx >= 0 && hidx < hlen) ? hist[hidx] : 0.0f;
                } else if (t < n_in) {
                    x = input[t];
                } else {
                    x = 0.0f;
                }
                acc += x * cp[k];
            }
        }
        output[n_out++] = acc;
    }

    /* Keep the last HIST_LEN samples for the next call. */
    int keep = hlen;
    int total = hlen + n_in;
    int src = total - keep;
    for (int i = 0; i < keep; i++) {
        if (src + i < hlen) {
            s->history[i] = hist[src + i];
        } else if (src + i - hlen < n_in) {
            s->history[i] = input[src + i - hlen];
        } else {
            s->history[i] = 0.0f;
        }
    }

    return n_out;
}

/* ---- 24k → 48k interpolator ---- */

void ring_resample_interp_init(ring_resample_interp_t *s)
{
    if (s != NULL) {
        memset(s->history, 0, sizeof(s->history));
        s->pos = 0;
    }
}

int ring_resample_interp_process(ring_resample_interp_t *s,
                                 const float *input, int n_in,
                                 float *output)
{
    if (s == NULL || input == NULL || output == NULL || n_in <= 0) {
        return 0;
    }
    int n_out = 0;
    int hlen = RING_RESAMPLE_INTERP_HIST_LEN;

    for (int i = 0; i < n_in; i++) {
        s->history[s->pos] = input[i];
        s->pos = (s->pos + 1) % hlen;

        for (int ph = 0; ph < RING_RESAMPLE_INTERP_PHASES; ph++) {
            float acc = 0.0f;
            const float *cp = ring_resample_interp_coeffs[ph];
            /* Both phases access the same input samples x[i], x[i-1], ..., x[i-11].
             * Linear history: latest at (pos-1), next at (pos-2), etc. */
            for (int k = 0; k < RING_RESAMPLE_INTERP_PHASE_LEN; k++) {
                int idx = (s->pos - 1 - k + hlen * 10) % hlen;
                acc += s->history[idx] * cp[k];
            }
            output[n_out++] = acc;
        }
    }
    return n_out;
}
